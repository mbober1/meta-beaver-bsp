LIC_FILES_CHKSUM = "file://docs/license.rst;md5=6ed7bace7b0bc63021c6eba7b524039e"
SRCREV = "da738d5eae93af342fdc4995dd3c05acb4c9d757"
SRC_URI = "git://git.trustedfirmware.org/TF-A/trusted-firmware-a.git;protocol=https;branch=master"


COMPATIBLE_MACHINE = "beagley-ai"

TFA_BUILD_TARGET = "all"
TFA_INSTALL_TARGET = "bl31"
