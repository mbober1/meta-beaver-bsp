COMPATIBLE_MACHINE = "beagley-ai"
